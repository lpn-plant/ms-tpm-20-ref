## zephyr/Kconfig
```kconfig
config TPM2_MS_REF
  bool "Enable Microsoft reference TPM implementation library"
  depends on WOLFSSL
```
